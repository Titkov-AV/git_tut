# IAR project start.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; IAR_ARMCM4_VG; USE_STM324xG_EVAL
  ICCARM.CCIncludePath2: ..; ..\include; ..\utils\include; ..\CortexLib\CMSIS\Device\ST\STM32F4xx\Include; ..\CortexLib\STM32F4xx_StdPeriph_Driver\inc; ..\CortexLib\Common\include; ..\crc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\include
  OBJCOPY.OOCOutputFile: start.bin
  ILINK.IlinkOutputFile: start.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CortexLib
    ../CortexLib/Common/src/: flash.c
    ../CortexLib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_crc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c
  group User
    ../src/: main.c stm32f4xx_it.c system_stm32f4xx.c
    ./: startup_stm32f4xx.s
  group utils
    ../utils/src/: utils.c
